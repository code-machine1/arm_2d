# Keil uVision project AT32F421C8T7_WorkBench.uvprojx, settings and files
target AT32F421C8T7_WorkBench (6220000::V6.22::ARMCLANG)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F421C8T7_WorkBench +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c wk_system.c wk_gpio.c
  group firmware
    ../../libraries/drivers/src/: at32f421_crm.c at32f421_gpio.c at32f421_pwc.c at32f421_debug.c at32f421_flash.c at32f421_misc.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
software components: Acceleration:Arm-2D Extras:Controls 2.3.0, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.6.5, Acceleration:Arm-2D Helper:Display Adapter 3.2.7, Acceleration:Arm-2D Helper:PFB 2.5.0, Acceleration:Arm-2D:Alpha-Blending 1.2.1, Acceleration:Arm-2D:Core 1.2.1, Acceleration:Arm-2D:Filter 1.2.1, Acceleration:Arm-2D:Transform 1.2.1, CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, CMSIS:DSP 1.15.0, Utilities:perf_counter:Core 2.4.0
